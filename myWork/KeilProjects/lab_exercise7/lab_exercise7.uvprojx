# Keil uVision project lab_exercise7.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab_exercise7
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ../../../courseRepo/Section 13_ (78) Interrupt priority and preemption/: led.c main.c
  group inc
    ../../../courseRepo/Section 13_ (78) Interrupt priority and preemption/: led.h my_board.h
software components: CMSIS:CORE 5.2.0, Device:Startup 2.6.2
